# Keil uVision project AT32F421_IAP.uvprojx, settings and files
target AT32F421_IAP (6230000::V6.23::ARMCLANG)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421_IAP +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: C:\Users\Administrator\Desktop\keil5_disp_size_bar.exe
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\system;..\app;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_usart.c iap.c wk_gpio.c wk_wdt.c wk_crc.c wk_adc.c wk_tmr.c wk_dma.c
    ../drive/: userconfig.h
  group system
    ../system/: tmt.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_adc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_crc.c at32f421_wdt.c at32f421_misc.c at32f421_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group app
    ../app/: PC_comm_handle.c beep_handle.c ec11_handle.c flash_handle.c key_handle.c PID_handle.c led_handle.c DS01_handle.c output_handle.c
  group driver
    ../drive/: at32_Usart.c util_queue.c adc_filter.c beep.c EncoderEC11.c flash.c key.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, Utilities:perf_counter:Core 2.5.2
